Commit message: feat: arm_tests

File: urc_arm/model/walli_arm.urdf (robot description, URDF)
Before this commit: robot walli, 9 links, 8 joints
Links:
- link spine: geometry collision mesh filename=collision/spine_collision.STL; visual mesh filename=visual/spine.STL
